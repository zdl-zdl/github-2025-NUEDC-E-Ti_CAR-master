# Keil uVision project empty_LP_MSPM0G3507_nortos_keil.uvprojx, settings and files
target MSPM0G3507_Project (6210000::V6.21::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: empty_LP_MSPM0G3507_nortos_keil +hex
  BeforeMake: cmd.exe /C "C:\ti\sysconfig_1.26.2\sysconfig_cli.bat" -o "C:\Users\Zhang\Desktop\github-2025-NUEDC-E-Ti_CAR-master" -s "C:\ti\mspm0_sdk_2_10_00_04\.metadata\product.json" --compiler keil "C:\Users\Zhang\Desktop\github-2025-NUEDC-E-Ti_CAR-master\empty.syscfg"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __MSPM0G3507__
  c include: C:\ti\mspm0_sdk_2_10_00_04\source;C:\ti\mspm0_sdk_2_10_00_04\source\third_party\CMSIS\Core\Include;..;..\User;..\Bsp;..\App;..\Control;..\Hardware
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: .\mspm0g3507.sct
  link misc: C:\ti\mspm0_sdk_2_10_00_04\source\ti\driverlib\lib\keil\m0p\mspm0g1x0x_g3x0x\driverlib.a
  group App
    ../App/: task.c task.h soundlight.c soundlight.h utils.c utils.h test.c test.h
  group Bsp
    ../Bsp/: timer.c timer.h uart.c uart.h delay.c delay.h
  group Hardware
    ../Hardware/: led.c led.h beep.c beep.h key.c key.h motor.c motor.h encoder.c encoder.h gray.c gray.h minipc.c minipc.h
  group Control
    ../Control/: track.c track.h speed.c speed.h dist.c dist.h pid.c pid.h
  group User
    ../User/: empty.c headfile.h
  group Source
    ../: empty.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
    ./: startup_mspm0g350x_uvision.s
